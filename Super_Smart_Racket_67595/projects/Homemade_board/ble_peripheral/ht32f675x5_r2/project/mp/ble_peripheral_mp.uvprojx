# Keil uVision project ble_peripheral_mp.uvprojx, settings and files
target ble_peripheral_mp (6240000::V6.24::ARMCLANG)
  device: HT32F67595_28LGA:CM33 Holtek
  pack: Holtek.HT32F675x5_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ble_peripheral_mp +hex
  AfterMake: cmd.exe /d /c call "..\..\project_HT32-IDE\mp\ble_peripheral_mp.bat" ".\Objects\ble_peripheral_mp"
  group Startup Code
    ../../../../../../sources/device/ht32f675x5/Source/: system_ARMCM33.c
    ../../../../../../sources/device/ht32f675x5/Source/GCC/: startup_ARMCM33_gcc.s
  group lib
    ../../../../../../libraries/boot2/: ht32f675x5_boot2_lib_r2_v1.1.c
    ../cp/: app_code_cp.c
    ../../../../../../libraries/patch/: ht32f675x5_patch_lib_mp_r2.a
    ../../../../../../libraries/rom/: ht32f675x5_rom_lib_mp_r2.a
  group components
    ../../../../../../sources/components/ht32f675x5_r2/app_debug/: app_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/err_debug/: err_debug.c
    ../../../../../../sources/components/ht32f675x5_r2/lpwr_ctrl/: lpwr_ctrl.c
  group main
    ./: main.c ei_main.cpp ei_main.h i2c.c ipc_general_blocking.c imu_frame.h
    ../me_lib/: ICM_20948_C.c imu_icm20948_i2c_dmp.c shared_buffer.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, CMSIS:NN Lib 4.0.0, EdgeImpulse:SDK 1.93.26, EdgeImpulse:model:Yxuan-TTS 9.0.0
